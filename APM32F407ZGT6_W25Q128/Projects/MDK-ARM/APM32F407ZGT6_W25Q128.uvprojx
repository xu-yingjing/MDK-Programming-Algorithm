# Keil uVision project APM32F407ZGT6_W25Q128.uvprojx, settings and files
target APM32F407ZGT6_W25Q128 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407ZG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APM32F407ZGT6_W25Q128
  AfterMake: cmd.exe /C copy "..\..\Output\%L" "..\..\Output\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F40X
  c include: ..\..\User;..\..\Drivers\CMSIS\Include;..\..\Drivers\APM32F4xx_StdPeriphDriver\inc;..\..\Drivers\Device\Geehy\APM32F4xx\Include;..\..\Drivers\BSP\inc;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\User\APM32F407ZGT6_W25Q128.lin
  link misc: --diag_suppress L6305
  group User
    ../../User/: FlashPrg.c FlashDev.c
  group Drivers/APM32F4xx_StdPeriphDriver
    ../../Drivers/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_gpio.c apm32f4xx_rcm.c apm32f4xx_spi.c
  group Drivers/BSP
    ../../Drivers/BSP/src/: bsp_norflash.c
  group Readme
    ../../: README.md
