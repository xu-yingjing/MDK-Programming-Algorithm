# Keil uVision project APM32E103ZET6_W25Q128.uvprojx, settings and files
target APM32E103ZET6_W25Q128 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APM32E103ZET6_W25Q128
  AfterMake: cmd.exe /C copy "..\..\Output\%L" "..\..\Output\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32E10X_HD
  c include: ..\..\User;..\..\Drivers\CMSIS\Include;..\..\Drivers\APM32E10x_StdPeriphDriver\inc;..\..\Drivers\Device\Geehy\APM32E10x\Include;..\..\Drivers\BSP\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\User\APM32E103ZET6_W25Q128.lin
  link misc: --diag_suppress L6305
  group User
    ../../User/: FlashPrg.c FlashDev.c
  group Drivers/APM32E10x_StdPeriphDriver
    ../../Drivers/APM32E10x_StdPeriphDriver/src/: apm32e10x_gpio.c apm32e10x_rcm.c apm32e10x_spi.c
  group Drivers/BSP
    ../../Drivers/BSP/src/: bsp_norflash.c
  group Readme
    ../../: README.md
